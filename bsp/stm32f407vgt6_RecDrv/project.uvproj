# Keil uVision project project.uvproj, settings and files
target rt-thread_stm32f4xx (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: rt_stm32f4_drv
  AfterMake: fromelf --bin --output=.\build\rt_stm32f4_drv.bin .\build\rt_stm32f4_drv.axf
  c flags: Optim=3 OneElfS=1
  c define: STM32F4XX, USE_STDPERIPH_DRIVER,HSE_VALUE=8000000,USE_USB_OTG_FS
  c include: .;..\..\components\finsh;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;Libraries\CMSIS\Include;Libraries\CMSIS\ST\STM32F4xx\Include;Libraries\STM32F4xx_StdPeriph_Driver\inc;applications;drivers;.\build;.\drivers\serial;.\drivers\include;.\drivers\include\drivers;.\app_712;.\app_712\gps;.\app_712\gsm;..\..\src;.\app_712\lcd;.\app_712\U4_485;.\app_712\protocol_808;.\app_712\HMI;.\app_712\rtc;.\drivers\include;.\app_712\dataflash;.\app_712\dataflash\SST25;.\app_712\printer;.\drivers\usb;..\..\components\dfs;..\..\components\dfs\include;..\..\components\dfs\src;..\..\components\dfs\filesystems\elmfat;..\..\components\dfs\filesystems\elmfat\option;..\..\components\dfs\filesystems\romfs;.\Libraries\STM32_USB_OTG_Driver\inc;.\Libraries\STM32_USB_OTG_Driver\src;.\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;.\Libraries\STM32_USB_HOST_Library\Class\MSC\src;.\Libraries\STM32_USB_HOST_Library\Core\inc;.\Libraries\STM32_USB_HOST_Library\Core\src;.\drivers\usb;.\drivers\spi_TF;.\app_712\CAN;.\app_712\shakesensor;.\app_712\ICcard
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*
  group Applications
    applications/: application.c startup.c
    ./app_712/: App_moduleConfig.h App_moduleConfig.c
  group Drivers
    drivers/: board.c stm32f4xx_it.c
    ./drivers/: board.h vuart.h vuart.c
  group STM32_StdPeriph
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group finsh
    ../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group gps_uart5
    ./app_712/gps/: gps.c gps.h
  group gsm_uart2
    ./app_712/gsm/: App_gsm.c App_gsm.h Device_gsm.c Device_gsm.h SMS.c SMS.h SMS_PDU.c SMS_PDU.h
  group 485_u4
    ./app_712/U4_485/: Device_485.c Device_485.h App_485.c App_485.h
  group protocol808
    ./app_712/protocol_808/: app_808.c app_808.h Device_808.c Device_808.h protocol_808.c protocol_808.h Sys_config.c Sys_config.h vdr.c
  group HMI
    ./app_712/HMI/: app_hmi.c app_hmi.h
  group RTC
    ./app_712/rtc/: rtc.c rtc.h
  group Dataflash
    ./app_712/dataflash/SST25/: SST25VF.c SST25VF.h
    ./app_712/dataflash/: Flash_Oper.h DF_Function.c DF_Function.h DF_Oper.c DF_Oper.h Flash_Oper.c
  group USB_Host
    ./drivers/usb/: usb_bsp.c usb_conf.h usbh.c usbh_conf.h usbh_usr.c usbh_usr.h
  group FileSystem
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
  group USB_StdLibrary
    ./Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ./Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
    ./Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd_int.c usb_hcd.c
  group SPI_TF
    ./drivers/spi_TF/: spi_sd.c spi_sd.h
  group Printer
    ./app_712/printer/: Device_printer.c Device_printer.h rtdevice.h
    ../../components/drivers/src/: ringbuffer.c
  group CAN
    ./app_712/CAN/: Device_CAN.c Device_CAN.h Device_CAN2.c Device_CAN2.h
  group shakesensor
    ./app_712/shakesensor/: mma8451.c mma8451.h
  group Lcd
    ./app_712/lcd/: bmp.c lcd.c Menu_0_0_password.c Menu_0_1_License.c Menu_0_2_CarType.c Menu_0_loggingin.c Menu_1_Idle.c Menu_2_1_Status8.c Menu_2_2_Speed15.c Menu_2_3_CentreTextStor.c Menu_2_4_CarInfor.c Menu_2_5_DriverInfor.c Menu_2_6_Mileage.c Menu_2_7_RequestProgram.c Menu_2_8_DnsIpDisplay.c Menu_2_InforCheck.c Menu_3_1_CentreQuesSend.c Menu_3_2_FullorEmpty.c Menu_3_3_ElectronicInfor.c Menu_3_4_Multimedia.c Menu_3_5_MultimediaTrans.c Menu_3_6_Record.c Menu_3_7_Affair.c Menu_3_8_LogOut.c Menu_3_InforInteract.c Menu_4_1_pilao.c Menu_4_2_chaosu.c Menu_4_InforTirExspd.c Menu_5_1_TelDis.c Menu_5_2_TelAtd.c menu_5_3_bdupgrad.c Menu_5_4_BDColdBoot.c Menu_5_5_Can.c Menu_5_6_Concuss.c Menu_5_7_Version.c Menu_5_8_usb.c Menu_5_other.c Menu_7_CentreTextDisplay.c Menu_Include.c SED1520.c Menu_0_4_VIN.c Menu_0_5_Colour.c Menu_0_3_Sim.c Menu_6_SetInfor.c Menu_8_1_MainDnsPort.c Menu_8_2_AuxDnsPort.c Menu_8_3_MainIpPort.c Menu_8_4_AuxIpPort.c Menu_8_5_ProDnsIp.c Menu_8_6_Apn.c Menu_8_SetDNS.c
  group ICcard
    ./app_712/ICcard/: IC_card.c SLE4442.c
